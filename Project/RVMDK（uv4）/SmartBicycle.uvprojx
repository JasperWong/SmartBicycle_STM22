# Keil uVision project SmartBicycle.uvprojx, settings and files
target MPU-DMP-EXAMPLE (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartBicycle +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F4
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User\Led;..\..\User\SysTick;..\..\User\lcd;..\..\User;..\..\User\Led;..\..\User\ledpoint;..\..\User\mlx9016;..\..\User\adc;..\..\User\TIMER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h bsp_usart1.c bicycle.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/lcd/: bsp_ili9341_lcd.c bsp_lcd.c
    ../../User/Led/: bicycle_led.c
    ../../User/ledpoint/: ledpoint.c
    ../../User/mlx9016/: bicycle_mlx9016.c
    ../../User/adc/: bsp_adc.c
    ../../User/TIMER/: timer.c
  group DOC
    ../../Doc/: readme.txt
